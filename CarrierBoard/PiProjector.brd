# Repository Puzzlers100/PI-CO-Project-or-

File README.md:

# PI-CO-Project-or-
A CM4 carrier board that allows for compatibility with DLPDLCR2000EVM, a small projector designed by TI for the BeagleBone Black

This Project is not yet finished, however should be completly functional

Shield: [![CC BY-SA 4.0][cc-by-sa-shield]][cc-by-sa]

This work is licensed under a
[Creative Commons Attribution-ShareAlike 4.0 International License][cc-by-sa].

[![CC BY-SA 4.0][cc-by-sa-image]][cc-by-sa]

[cc-by-sa]: http://creativecommons.org/licenses/by-sa/4.0/
[cc-by-sa-image]: https://licensebuttons.net/l/by-sa/4.0/88x31.png
[cc-by-sa-shield]: https://img.shields.io/badge/License-CC%20BY--SA%204.0-lightgrey.svg

## EAGLE design CarrierBoard/PiProjector.brd

Parts:
+3.3V, +5V: TP1R
ACT_LED: TP1R
C1, C2, C3, C4, C7, C21, C23, C25, C28, C29, C30, C31: 100n; 0603R
C5, C6, C9, C10, C11, C26: 10u; 0603R
C8, C16, C17, C27: 100u; 1206D-R
C12, C13: 27p; 0603R
C14, C15: 20p; 0603R
C18: 1u; 0603R
C19, C20, C22, C24: 4.7u; 0603R
D1, D2: D-BRIDGE; U-DFN3030-4
D4: PD3S160; POWERDI323
GLOBAL_EN: TP1R
GND: TP1R
LED1: LEDSML1206; SML1206
P8, P9: PINHEAD2X23
PWR_LED: TP1R
Q2: BSS84; SOT23
R1, R7: 12K; 0603R
R2, R17: 10K; 0603R
R3, R4, R5, R6: 36K; 0603R
R8, R10, R11: 330; 0603R
R9: 15K; 0603R
R12, R13: 22; 0603R
R14: 1.5K; 0603R
R15, R16: 5.1K; 0603R
RPI-CM1: RPI-CM4
SLAVE_SWITCH: PINHD-1X2; 1X02
U$1: FSUSB42MUX
U$2: USD2514BI; USB2514BM2
U$3: AP22653W6
U$4: KUSBX-SL-CS1N14-B
U$5: RJ45-5-2337992-8
U$6: CM108B
U$7: SJ-43514-SMT-TR
U$8, U$9, U$10: USBA-87520
U$11: 472192001
U$12, U$15: RT9742GGJ5
U$13: HDMI0-467650001; 0467650001
X1: 24MHz; X2016
X2: 12Mhz; X2520

Connections:
!RPIBOOT: D4.A, RPI-CM1.93 (!RPIBOOT)
+3.3V: +3.3V.1, C1.A (1), C2.A (1), C3.A (1), C4.A (1), C5.A (1), C6.A (1), C31.A (1), P9.3, Q2.2 (S), R1.B (2), R17.A (1), RPI-CM1.78 (GPIO_VREF), RPI-CM1.84 (CM4_3.3V(OUTPUT)), RPI-CM1.86 (CM4_3.3V(OUTPUT)), U$1.VCC, U$2.VBUS_DET, U$2.VDD33.1, U$2.VDD33.2, U$2.VDDA33.1, U$2.VDDA33.2, U$2.VDDA33.3, U$2.VDDA33.4, U$5.15 (LEDG+), U$5.17 (LEDY+), U$12.5 (IN)
+5V: +5V.1, C27.2, C28.A (1), C29.B (2), P8.3, P8.4, P9.7, P9.8, RPI-CM1.77 (+5V(INPUT)), RPI-CM1.79 (+5V(INPUT)), RPI-CM1.81 (+5V(INPUT)), RPI-CM1.83 (+5V(INPUT)), RPI-CM1.85 (+5V(INPUT)), RPI-CM1.87 (+5V(INPUT)), U$3.1 (IN), U$4.A04 (VBUS), U$4.A09 (VBUS), U$4.B04 (VBUS), U$4.B09 (VBUS), U$15.5 (IN)
AUX_N: R12.B (2), U$6.42 (USBDM)
AUX_P: R13.A (1), U$6.41 (USBDP)
D_N: RPI-CM1.103 (USB_N), U$1.D_N
D_P: RPI-CM1.105 (USB_P), U$1.D_P
GND: C1.B (2), C2.B (2), C3.B (2), C4.B (2), C5.B (2), C6.B (2), C7.A (1), C8.2, C9.A (1), C10.A (1), C11.A (1), C12.B (2), C13.B (2), C14.B (2), C15.B (2), C19.B (2), C20.B (2), C21.A (1), C22.B (2), C23.A (1), C24.A (1), C25.A (1), C26.B (2), C27.1, C28.B (2), C29.A (1), C30.A (1), C31.B (2), GND.1, LED1.C, P8.1, P8.2, P9.1, P9.2, P9.44, P9.45, P9.46, R2.B (2), R3.B (2), R4.B (2), R5.B (2), R6.B (2), R7.A (1), R9.B (2), R15.A (1), R16.A (1), RPI-CM1.1 (GND), RPI-CM1.2 (GND), RPI-CM1.7 (GND), RPI-CM1.8 (GND), RPI-CM1.13 (GND), RPI-CM1.14 (GND), RPI-CM1.22 (GND), RPI-CM1.23 (GND), RPI-CM1.32 (GND), RPI-CM1.33 (GND), RPI-CM1.42 (GND), RPI-CM1.43 (GND), RPI-CM1.52 (GND), RPI-CM1.53 (GND), RPI-CM1.59 (GND), RPI-CM1.60 (GND), RPI-CM1.65 (GND), RPI-CM1.66 (GND), RPI-CM1.71 (GND), RPI-CM1.74 (GND), RPI-CM1.98 (GND), RPI-CM1.107 (GND), RPI-CM1.108 (GND), RPI-CM1.113 (GND), RPI-CM1.114 (GND), RPI-CM1.119 (GND), RPI-CM1.120 (GND), RPI-CM1.125 (GND), RPI-CM1.126 (GND), RPI-CM1.131 (GND), RPI-CM1.132 (GND), RPI-CM1.137 (GND), RPI-CM1.138 (GND), RPI-CM1.144 (GND)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
GPIO2: P8.27, RPI-CM1.58 (GPIO2)
GPIO3: P8.29, RPI-CM1.56 (GPIO3)
GPIO4: P8.16, RPI-CM1.54 (GPIO4)
GPIO5: P8.34, RPI-CM1.34 (GPIO5)
GPIO6: P8.35, RPI-CM1.30 (GPIO6)
GPIO7: P8.33, RPI-CM1.37 (GPIO7)
GPIO8: P8.31, RPI-CM1.39 (GPIO8)
GPIO9: P8.32, RPI-CM1.40 (GPIO9)
GPIO10: P8.42, RPI-CM1.44 (GPIO10)
GPIO11: P8.39, RPI-CM1.38 (GPIO11)
GPIO12: P8.40, RPI-CM1.31 (GPIO12)
GPIO13: P8.37, RPI-CM1.28 (GPIO13)
GPIO14: P8.38, RPI-CM1.55 (GPIO14)
GPIO15: P8.36, RPI-CM1.51 (GPIO15)
GPIO16: P8.15, RPI-CM1.29 (GPIO16)
GPIO17: P8.45, RPI-CM1.50 (GPIO17)
GPIO18: P8.46, RPI-CM1.49 (GPIO18)
GPIO19: P8.43, RPI-CM1.26 (GPIO19)
GPIO20: P8.44, RPI-CM1.27 (GPIO20)
GPIO21: P8.41, RPI-CM1.25 (GPIO21)
GPIO22: P9.15, RPI-CM1.46 (GPIO22)
GPIO25: P8.18, RPI-CM1.41 (GPIO25)
GPIO26: P8.26, RPI-CM1.24 (GPIO26)
GPIO27: P9.43, RPI-CM1.48 (GPIO27)
HDMI0_N: RPI-CM1.184 (HDMI0_TX0_N), U$13.11 (HDMI0_N)
HDMI0_P: RPI-CM1.182 (HDMI0_TX0_P), U$13.9 (HDMI0_P)
HDMI1_N: RPI-CM1.178 (HDMI0_TX1_N), U$13.8 (HDMI1_N)
HDMI1_P: RPI-CM1.176 (HDMI0_TX1_P), U$13.6 (HDMI1_P)
HDMI2_N: RPI-CM1.172 (HDMI0_TX2_N), U$13.5 (HDMI2_N)
HDMI2_P: RPI-CM1.170 (HDMI0_TX2_P), U$13.3 (HDMI2_P)
HDMICLK_N: RPI-CM1.190 (HDMI0_CLK_N), U$13.14 (CLK_N)
HDMICLK_P: RPI-CM1.188 (HDMI0_CLK_P), U$13.12 (CLK_P)
HDMI_CEC: RPI-CM1.151 (HDMI0_CEC), U$13.15 (CEC)
HDMI_HOTPLUG: RPI-CM1.153 (HDMI0_HOTPLUG), U$13.1 (HOTPLUG)
HDMI_SCL: RPI-CM1.200 (HDMI0_SCL), U$13.17 (SCL)
HDMI_SDA: RPI-CM1.199 (HDMI0_SDA), U$13.18 (SDA)
ID_SC: P8.30, RPI-CM1.35 (ID_SC)
ID_SD: P8.28, RPI-CM1.36 (ID_SD)
LEDG: R10.B (2), RPI-CM1.15 (ETH_!LED3)
LEDY: R11.B (2), RPI-CM1.17 (ETH_!LED2)
MUTP: P8.7, U$6.18 (MUTEP)
MUTR: P8.8, U$6.6 (MUTER)
unnamed: PWR_LED.1, RPI-CM1.95 (PI_LED_!PWR)
unnamed: ACT_LED.1, RPI-CM1.21 (PI_!LED_ACTIVITY)
unnamed: RPI-CM1.57 (SD_CLK), U$11.5 (CLK)
unnamed: R10.A (1), U$5.16 (LEDG-)
unnamed: RPI-CM1.61 (SD_DAT3), U$11.2 (DAT3)
unnamed: RPI-CM1.69 (SD_DAT2), U$11.1 (DAT2)
unnamed: D4.C, Q2.1 (G), R17.B (2), SLAVE_SWITCH.1
unnamed: C16.1, U$6.32 (LOR)
unnamed: R3.A (1), U$2.HS_IND/CFG_SEL1
unnamed: R4.A (1), U$2.SUSP_IND/LOCAL_PWR/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 (SUSP_IND/LOCAL_PWR/NON_REMO)
unnamed: R5.A (1), U$2.SDA/SMBDATA/NON_REM1 (SDA/SMBDATA/NONREM1)
unnamed: R6.A (1), U$2.SCL/SMBCLK/CFG_SEL0 (SCL/SMBCLK/CFG_SELO)
unnamed: R11.A (1), U$5.18 (LEDY-)
unnamed: C18.A (1), U$6.27 (MICIN)
unnamed: C17.2, U$7.2 (LEFT)
unnamed: C16.2, U$7.3 (RIGHT)
unnamed: C17.1, U$6.30 (LOL)
unnamed: C18.B (2), U$7.1 (MIC)
unnamed: RPI-CM1.63 (SD_DAT0), U$11.7 (DAT0)
unnamed: RPI-CM1.67 (SD_DAT1), U$11.8 (DAT1)
unnamed: R7.B (2), U$2.RBIAS
unnamed: LED1.A, R8.B (2)
unnamed: R9.A (1), U$3.5 (ILIM)
unnamed: U$2.PRTPWR1/BC_EN1, U$3.3 (EN)
unnamed: U$2.OCS_N1, U$2.OCS_N2, U$2.OCS_N3, U$2.OCS_N4, U$3.4 (/FAULT)
unnamed: RPI-CM1.62 (SD_CMD), U$11.3 (CMD)
unnamed: R1.A (1), RPI-CM1.75 (SD_PWR_ON), U$12.4 (EN)
unnamed: C7.B (2), U$5.4, U$5.5
unnamed: C26.A (1), U$11.4 (VDD), U$12.1 (OUT)
unnamed: D2.3 (AC2), U$5.14 (VC4)
unnamed: D2.1 (AC1), U$5.13 (VC3)
unnamed: C30.B (2), U$13.19 (+5V), U$15.1 (OUT)
unnamed: D1.1 (AC1), U$5.12 (VC2)
unnamed: GLOBAL_EN.1, RPI-CM1.99 (GLOBAL_EN)
unnamed: R16.B (2), U$4.A05 (CC1)
unnamed: R15.B (2), U$4.B05 (CC2)
unnamed: C12.A (1), U$2.XTALIN/CLKIN (TALIN/CLKIN), X1.1
unnamed: C13.A (1), U$2.XTALOUT (TALOUT), X1.3 (2)
unnamed: D1.3 (AC2), U$5.11 (VC1)
unnamed: C14.A (1), U$6.8 (XI), X2.1
unnamed: C15.A (1), U$6.9 (XO), X2.3 (2)
PAIR0_N: RPI-CM1.10 (ETH_PAIR0_N), U$5.2
PAIR0_P: RPI-CM1.12 (ETH_PAIR0_P), U$5.1
PAIR1_N: RPI-CM1.6 (ETH_PAIR1_N), U$5.6
PAIR1_P: RPI-CM1.4 (ETH_PAIR1_P), U$5.3
PAIR2_N: RPI-CM1.9 (ETH_PAIR2_N), U$5.8
PAIR2_P: RPI-CM1.11 (ETH_PAIR2_P), U$5.7
PAIR3_N: RPI-CM1.5 (ETH_PAIR3_N), U$5.10
PAIR3_P: RPI-CM1.3 (ETH_PAIR3_P), U$5.9
POE+: D1.2 (+), D2.2 (+), P8.5
POE-: D1.4 (-), D2.4 (-), P8.6
REGV: C20.A (1), R14.B (2), U$6.37 (REGV), U$6.38 (MSEL)
RESET_N: RPI-CM1.100 (!EXTRST), U$2.RESET_N
SCL: P9.19, RPI-CM1.45 (GPIO24)
SDA: P9.20, RPI-CM1.47 (GPIO23)
SELECT: Q2.3 (D), R2.A (1), R8.A (1), RPI-CM1.101 (USB_OTG_ID), U$1.SEL
USB1_N: U$2.USBDM_DN1/PRT_DIS_M1, U$8.2 (D_N)
USB1_P: U$2.USBDM_DN1/PRT_DIS_P1 (USBDP_DN1/PRT_DIS_P1), U$8.3 (D_P)
USB2D_N: R12.A (1), U$2.USBDM_DN2/PRT_DIS_M2 (USBDM_DN1/PRT_DIS_M2)
USB2D_P: R13.B (2), R14.A (1), U$2.USBDM_DN2/PRT_DIS_P2 (USBDP_DN1/PRT_DIS_P2)
USB3D_N: U$2.USBDM_DN3/PRT_DIS_M3 (USBDM_DN1/PRT_DIS_M3), U$9.2 (D_N)
USB3D_P: U$2.USBDM_DN3/PRT_DIS_P3 (USBDP_DN1/PRT_DIS_P3), U$9.3 (D_P)
USB4_N: U$2.USBDM_DN4/PRT_DIS_M4 (USBDM_DN1/PRT_DIS_M4), U$10.2 (D_N)
USB4_P: U$2.USBDM_DN4/PRT_DIS_P4 (USBDP_DN1/PRT_DIS_P4), U$10.3 (D_P)
USB5D_N: U$1.HSD1_M, U$4.A07 (DN1), U$4.B07 (DN2)
USB5D_P: U$1.HSD1_P, U$4.A06 (DP1), U$4.B06 (DP2)
USB6_N: U$1.HSD0_M, U$2.USBDM_UP
USB6_P: U$1.HSD0_P, U$2.USBDP_UP
VBUS: C8.1, C9.B (2), C10.B (2), C11.B (2), C21.B (2), C22.A (1), C23.B (2), C24.B (2), C25.B (2), U$3.6 (OUT), U$6.29 (AVDD1), U$6.34 (AVDD2), U$6.35 (DVDD), U$8.1 (VBUS), U$9.1 (VBUS), U$10.1 (VBUS)
VLDN: P8.10, U$6.48 (VOLDN)
VLUP: P8.9, U$6.39 (VOLUP)
VREF: C19.A (1), U$6.26 (VREF)

Notes on the sheet:
USB

Board: 4 copper layers, 85.8 x 54.0 mm, 79 parts (69 on the bottom side), 122 nets.

## EAGLE design DaughterBoard/DaughterBoard.brd

Parts:
1A, 1B, 2A, 2B: TP1R
C1, C2: 1u; 0603R
C3: C0603R; 0603R
JP1, JP2: PINHD-2X10; 2X10
R1, R2: 10k; 0603R
R3, R4: 8k; 0603R
U$1: MYBSP00502ABF
U$2, U$3, U$4, U$5, U$7, U$8: BTN-222CJVABR; BTN-22CJVABR
U$6: GPIOEX_TCA9539PWR
U$9: DRIVER_LV8716QA-MH; DRIVER-LV8716QA-MH

Connections:
+3.3V: C3.A (1), JP2.18, R1.B (2), R2.B (2), U$6.!RST, U$6.VCC
+5V: C1.A (1), C2.B (2), JP1.17, JP1.18, U$1.4 (VOUT+), U$9.VM1, U$9.VM2
GND: C1.B (2), C2.A (1), C3.B (2), JP1.19, JP1.20, R3.B (2), R4.B (2), U$1.3 (VOUT-), U$2.1, U$2.2, U$3.1, U$3.2, U$4.1, U$4.2, U$5.1, U$5.2, U$6.A0, U$6.A1, U$6.GND, U$7.3, U$7.4, U$8.3, U$8.4, U$9.GND, U$9.GND2, U$9.PGND1, U$9.PGND2
MUTP: JP1.14, U$5.3, U$5.4
MUTR: JP1.13, U$3.3, U$3.4
unnamed: R1.A (1), U$6.P14, U$8.1, U$8.2
unnamed: R2.A (1), U$6.P15, U$7.1, U$7.2
unnamed: R4.A (1), U$9.RCS2
unnamed: R3.A (1), U$9.RCS1
unnamed: U$6.P00, U$9.IN1
unnamed: U$6.P01, U$9.IN2
unnamed: U$6.P02, U$9.IN3
unnamed: U$6.P03, U$9.IN4
unnamed: U$6.P04, U$9.PS
unnamed: 2A.1, U$9.OUT2A
unnamed: 2B.1, U$9.OUT2B
unnamed: 1B.1, U$9.OUT1B
unnamed: 1A.1, U$9.OU1A (OUT1A)
POE+: JP1.16, U$1.1 (VIN+)
POE-: JP1.15, U$1.2 (VIN-)
SCL: JP2.2, U$6.SCL
SDA: JP2.1, U$6.SDA
VLDN: JP1.11, U$2.3, U$2.4
VLUP: JP1.12, U$4.3, U$4.4

Board: 2 copper layers, 26.5 x 54.5 mm, 22 parts (0 on the bottom side), 24 nets.

## Commit log

2021-02-24 Imported all work to Github
2021-02-24 Fixed license
2021-02-25 POE connection Moved
    Started Modification for Adjusted POE connection
2021-02-25 Finished modified daughterboard
2021-03-01 minor fix
2021-03-08 Testing nRPIBOOT fix
2021-03-08 Need PM labs
    replace transistor with pfet and diode with shotkey diode
2021-03-09 Fixed rpiboot
2021-03-09 Fixed RPI and USB switch Pulldown
2021-03-09 minor fixes
2021-03-28 Added an I2C expander
2021-03-28 Added a motor Driver
2021-06-11 Missing Reset Pin on I2C Gpio Expander
    GPIO expander stuck in permanent reset because RST pin needs to be connected to VCC
2021-06-12 looks better
2021-10-25 forgot to push last version after sending to OSH
2021-10-25 Modified POE route to avoid clearence issues
2021-11-28 Added images and Rerouted POE
2024-01-24 CaseModel
    Included the case model, internal support for motor and Image of both
